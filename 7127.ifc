Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-20T16:37:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.0.490.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 20 16:37:54 2018 * Host: DESKTOP-23GQEAI * Database: C:\Users\vladb\AppData\Local\Temp\{6BF51E71-1ADA-4D09-8319-3CF5AAE4D83F}\ifc * Database version: 5507 * Database creation date: Mon Aug 20 16:37:54 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 20 16:37:54 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 20 16:37:54 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7127 Body for shower faucet, 7127:7127 Body for shower faucet:336230
In: Level 1
Type - PredefinedType: FAUCET; Material: Plastic, Opaque Black, Brass
Type - Dimensions - InletConnectionSize: 20 mm; NominalHeight: 247 mm; NominalWidth: 185 mm
Type - General - Author: Convergo AB; BIMObjectName: 7127; ConvergoRefNr: 0087-1809-0021-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_65_52_61_15; Uniclass2015Description: Concealed intumescent pipe collars; Uniclass2015Reference: Pr_65_52_61_15; Version: 1; VersionDate: 01/07/2018
Type - Green Building Properties - EAN Number: 6414150050527; Noise Class: II (ISO 3822)
Type - Identity Data - Class: Concealed; Group: Shower faucets; Manufacturer: Oras; Market: INT;EST;LVA;LTU;POL;RUS;UKR; Model: 7127 Body for shower faucet; Name_en: 7127 Body for shower faucet; OmniClass Number: 23.45.55.11; OmniClass Title: Sanitary Components; Product Code: 7127; Product Datasheet: https://www.oras.com/datasheet/7127/en; Product Family: Oras; Product URL: https://www.oras.com/en/products/oras/product/7127; Type Name: 7127 Body for shower faucet
Type - Materials and Finishes - BaseunitMainMaterial: Brass
Type - Mechanical - Connection Size: G1/2; Eco Flow At 300kPa: 0.00021 m3/s; Flow Rate At 300kPa: 0.00027 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110265_PDM_945528_7_(945528-06-14).pdf; Installation Type: Wall mounted concealed; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 165000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP7127/
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7127; Features: Concealed; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7127; Name: 7127 Body for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 185x102/45x247 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7127; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7127 Body for shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; NotTrimKitVisibility: no; Offset: 0 mm; TrimKitVisibility: yes
Dimensions - Area: 0.155522 m2; NominalDepth: 102 mm; Volume: 0.00466031 m3
Identity Data - Mark: 9
Mechanical - System Classification: Sanitary,Domestic Cold Water,Domestic Hot Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7127: 7127 Body for shower faucet; Family and Type: 7127: 7127 Body for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7127: 7127 Body for shower faucet; Type Id: 7127: 7127 Body for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
